# Keil uVision project Project.uvprojx, settings and files
target STM32746G_DISCOVERY (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32746G_DISCOVERY
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,USE_STM32746G_DISCOVERY
  c misc: --C99
  c include: .\User\Include;.\Drivers\BSP\STM32F746G-Discovery\Include;.\Drivers\STM32F7xx_HAL_Driver\Include;.\Drivers\BSP\STM32F746G-Discovery;.\Drivers\BSP\Components\ft5336;.\Drivers\BSP\Components\rk043fn48h;.\Utilities\Fonts
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Example/MDK-ARM
    ./: startup_stm32f746xx.s
  group Drivers/CMSIS
    ./Drivers/CMSIS/Source/: system_stm32f7xx.c
  group Example/User
    ./User/Source/: main.c stm32f7xx_hal_msp.c stm32f7xx_it.c init.c ultrasonic.c
    ./User/Include/: ultrasonic.h
  group Drivers/STM32F7xx_HAL_Driver
    ./Drivers/STM32F7xx_HAL_Driver/Source/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_uart.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c
  group Drivers/BSP/STM32746G-Discovery
    ./Drivers/BSP/STM32F746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_lcd.c stm32746g_discovery_ts.c stm32746g_discovery_sdram.c
  group Drivers/BSP/Components
    ./Drivers/BSP/Components/ft5336/: ft5336.c
software components: CMSIS:CORE 4.3.0
